Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Shelving-Storage_EFG_EFG-Pulse-Storage-800x3A4.ifc
Time: 2021-06-02T13:24:22
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: EFG Pulse Storage 800x3A4
ePset_BIMobjectScript - Base type: Plastic plinth; Type: S80A30; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): EFG Pulse Storage 800x3A4; SKU (BO_prodsku): efgpulsestorage_8003a4; ManufacturName (BO_Manufac): EFG; BrandUrl (BO_brandurl): http://www.efg.se; ProductFamily (BO_prodfam): Furniture; ProductGroup (BO_prodgroup): Storage; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 4/26/2018; EditionNumber (BO_edinum): 1; Width (BO_width): 0; Height (BO_height): 0; Depth (BO_depth): 0; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/efg/product/efgpulsestorage_8003a4; ProductDataUrl (BO_prodaturl): bimobject.com/efg/product/efgpulsestorage_8003a4; ProductUrl (BO_producturl): http://www.efg.info/Products/Storage/EFG-Pulse; MaterialMain (BO_mainmat): Wood; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Shelving & Storage; BimObjectCategoryCode (BO_bocat_code): furniture-shelving-storage; IfcClassification (BO_ifcclas): Furniture; UnspscCode (BO_unspsc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8211; Uniclass14Description (BO_uniclass_1_4_desc): Furniture; Uniclass20Code (BO_uniclass_2_0_code): PR-31-77; Uniclass20Description (BO_uniclass_2_0_desc): Shelves And Storage Units; NBSReference (BO_nbs_ref): 31-77; NBSReferenceDescription (BO_nbs_desc): Shelves And Storage Units; OmniClassCode (BO_omniclass_code): 23-21 00 00; OmniClassDescription (BO_omniclass_name): Furnishings, Fixtures and Equipment Products; MasterFormat2014Code (BO_masterformat2014_code): 12 00 00; MasterFormat2014Description (BO_masterformat2014_name): Furnishings; UniFormat2Code (BO_uniformat2_code): E; UniFormat2Description (BO_uniformat2_name): EQUIPMENT & FURNISHINGS; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA
